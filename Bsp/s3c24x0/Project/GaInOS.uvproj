# Keil uVision project GaInOS.uvproj, settings and files
target GaInOS (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: GaInOS
  c flags: Optim=3
  c include: ..\Bsp\Cpu;..\Bsp\Serial;..\vPort;..\..\..\include;..\..\..\kernel;..\..\..\osek_test\GaInOS_Studio
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x400000
  memory RVCT6: RAM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Boot
    ../vPort/: start_rvds.S
  group vPort
    ../vPort/: vPort.c vPort.h vPort_Rvds.S s3c2440.h
  group include
    ../../../include/: MemMap.h Os.h Std_Types.h
  group kernel
    ../../../kernel/: Alarm.c Alarm.h Autosar.c Autosar.h Event.c Event.h Hooks.c Interrupt.c Interrupt.h Kernel.h OsCfgChk.h Osctrl.c Osctrl.h Resource.c Resource.h Task.c Task.h
  group Bsp
    ../Bsp/Serial/: Serial.c
    ../Bsp/Cpu/: Cpu.c
  group Cfg
    ../../../osek_test/GaInOS_Studio/: CfgObj.c CfgRdyQ.c CfgSchedTbl.c CfgObj.h Os_Cfg.h
  group Source
    ./Source/: main.c
